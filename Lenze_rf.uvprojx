# Keil uVision project Lenze_rf.uvprojx, settings and files
target LenzeRF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Lenze_rf +hex
  AfterMake: fromelf.exe .\Objects\Lenze_rf.axf --i32combined --output .\bin\Lenze_rf.hex
  AfterMake: fromelf -c -a -d -e -v -o Lenze_rf.asm ./Objects/Lenze_rf.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1  HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0 DEBUG_INFO=1 PHY_MODE_DEF=1 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: .\include;.\source;.\misc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: .\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group app
    ./source/: OSAL_LenzePhy.c Lenze_phy.c
  group driver
    ./components/: uart.c clock.c gpio.c timer.c pwrmgr.c my_printf.c flash.c fs.c
  group jump
    ./misc/: jump_table.c
  group lib
    ./lib/: rf.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
